Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:19+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-TRM-OCTAGO
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Батут уличный, ZSK-TRM-OCTAGO Батут «Восьмиугольник»
In: Площадка
Description: Батут уличный. Батут «Восьмиугольник»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-TRM-OCTAGO; ModelReference: Батут «Восьмиугольник»; ProductionYear: 2026; ArticleNumber: ZSK-TRM-OCTAGO
ORION_Изделие - Артикул: ZSK-TRM-OCTAGO; Артикул прежний: SD-TRM-OCTAGO; Наименование: Батут «Восьмиугольник»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Ø 3000 мм; Цена: 1 000 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/trampolines/30815; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Батут «Восьмиугольник»; ADSK_Марка: ZSK-TRM-OCTAGO; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/trampolines/30815
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-TRM-OCTAGO
Qto_ORION - Длина: 3000 mm; Ширина: 3000 mm; Высота: 3000 mm
